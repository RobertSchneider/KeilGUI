# Keil uVision project main_LPC17xx.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1758 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: main +hex
  c flags: Optim=1 OneElfS=1
  c define: _KEIL, LPC1758
  c include: .\src;..\EmbSysLib\Lib\Src
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ../EmbSysLib/Lib/Src/Hardware/MCU/LPC17xx/Sys/Keil/: startup_LPC17xx.s RTOS_Asm.s
    ../EmbSysLib/Lib/Src/: lib.cpp
    ../EmbSysLib/Lib/Src/Module/: RTOS.cpp
    ./Src/: main.cpp IDrawable.h View.cpp View.h Rect.h GUI.h GUIButton.cpp GUIButton.h GUIControls.cpp GUIControls.h GUILabel.cpp GUILabel.h GUISelect.cpp GUISelect.h IEventHandler.h GUIPagedView.cpp GUIPagedView.h GUIMeasurement.cpp GUIMeasurement.h GUIStepper.cpp GUIStepper.h GUITitleView.h GUI.cpp
